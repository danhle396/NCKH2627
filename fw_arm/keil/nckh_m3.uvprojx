# Keil uVision project nckh_m3.uvprojx, settings and files
target NCKH2627_M3 (6240000::V6.24::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(27000000) ELITTLE
  output: nckh_m3 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MICROLIB
  c include: ..\src\core;..\src\app;..\src\driver;..\src\gen
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\gw1ns4c_8k.sct
  link misc: --entry=Reset_Handler --info=sizes,totals
  group core
    ../src/core/: cnn_core.c safety.c preprocess.c blocks.c pwr_btn.c imu_guard.c wifi_at.c gyro_cal.c raw_log.c nga_bt.c
  group driver
    ../src/driver/: startup.c board.c uart.c i2c_mem.c imu.c cnn_drv.c
  group app
    ../src/app/: main.c app.c web.c
  group gen
    ../src/gen/: cnn_rom_inc.c trang_web_gz.c
